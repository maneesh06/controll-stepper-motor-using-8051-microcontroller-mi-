# Keil uVision project CONTROLL_STEPPER_MOTOR.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: CONTROLL_STEPPER_MOTOR +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: controll stepper motor.c
